# Keil uVision project 任务3.通过继电器控制外部灯2s闪烁一次.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: 任务3.通过继电器控制外部灯2s闪烁一次 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源程序组 1
    ./: 任务3.通过继电器控制外部灯2s闪烁一次.c
