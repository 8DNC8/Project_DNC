# Keil uVision project 任务15.用DS18B20测量温度并用数码管显示.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: 任务15.用DS18B20测量温度并用数码管显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源程序组 1
    ./: 任务15.用DS18B20测量温度并用数码管显示.c
